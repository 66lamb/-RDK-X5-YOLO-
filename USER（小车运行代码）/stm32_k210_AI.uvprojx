# Keil uVision project stm32_k210_AI.uvprojx, settings and files
target stm32_k210_AI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_K210_AI +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CMSIS;..\FWLib\inc;..\BSP;..\BSP\icm20607;..\BSP\LCD;..\BSP\RGB;..\BSP\w25q64;..\APP;..\BSP\UART;..\BSP\TIMER;..\BSP\motor;..\BSP\KEY;..\BSP\PID;..\BSP\TIMER;..\BSP\tbdetails
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f10x_it.c
  group CMSIS
    ../CMSIS/: system_stm32f10x.c core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../BSP/LCD/: lcd.c lcd_init.c
    ../BSP/: bsp.c delay.c
    ../BSP/icm20607/: bsp_icm20607.c IOI2C.c
    ../BSP/w25q64/: bsp_w25q64.c bsp_spi.c
    ../BSP/RGB/: bsp_RGB.c
    ../BSP/UART/: bsp_usart.c
    ../BSP/motor/: bsp_encoder.c bsp_motor.c
    ../BSP/KEY/: bsp_key.c
    ../BSP/PID/: bsp_pid.c
    ../BSP/TIMER/: bsp_timer.c
    ../BSP/tbdetails/: tbdetails.c
  group APP
    ../APP/: falsh_use.c app_math.c imu_use.c app_motor.c app_mecanum.c k210_AI_deal.c
